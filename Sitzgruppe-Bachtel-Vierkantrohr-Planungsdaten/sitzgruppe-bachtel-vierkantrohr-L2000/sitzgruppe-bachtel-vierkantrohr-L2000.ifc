Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-10-19T17:53:19+02:00
Written by: IfcOpenShell 0.9.0.post1
Made in: IfcOpenShell 0.9.0.post1
Authorization: Nobody

# IfcFurniture: Sitzgruppe, Sitzgruppe Bachtel Vierkantrohr, L 2000 mm
In: Standort
Pset_ManufacturerTypeInformation - Manufacturer: Obersee Holzwerke (Karawan Holz GmbH); ModelLabel: Sitzgruppe Bachtel Vierkantrohr, L 2000 mm; ModelReference: BACHTEL-VKT-2000-STD
OH_Abmessungen - Laenge_mm: 2000; Tiefe_mm: 1540; Tischhoehe_mm: 760; Sitzhoehe_mm: 453; Gewicht_ca_kg: 144; Stuetze: Vierkantrohr 80 × 80 × 4 mm; Rollstuhlplatz: no; Material: Lärche, Stahl S235 feuerverzinkt + pulverbeschichtet schwarz matt
